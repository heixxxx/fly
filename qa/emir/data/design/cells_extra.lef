VERSION 5.8 ;
UNITS
   DATABASE MICRONS 2000 ;
END UNITS

VIA VIA12
   LAYER M1 ;
      RECT -0.20 -0.20 0.20 0.20 ;
   LAYER VIA1 ;
      RECT -0.08 -0.08 0.08 0.08 ;
   LAYER M2 ;
      RECT -0.24 -0.24 0.24 0.24 ;
END VIA12

MACRO INV_X1
   CLASS BLOCK ;
   SIZE 9.9 BY 9.9 ;
END INV_X1

END LIBRARY
