VERSION 5.8 ;
UNITS
   DATABASE MICRONS 2000 ;
END UNITS
LAYER M1
   TYPE ROUTING
END M1
